# Keil uVision project AT32F403A_LVGL_9.uvprojx, settings and files
target Target 1 (6190000::V6.19::ARMCLANG)
  device: -AT32F403ACGU7 ArteryTek
  pack: ArteryTek.AT32F403A_407_DFP.2.1.9
  cpu: IRAM(0x20000000,0x38000) IROM(0x08000000,0x100000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: template +hex
  c flags: Optim=2 OneElfS=1 uC99=1 uGnu=1 v6Lang=3 v6LangP=5 wLevel=3
  c define: AT32F403ACGU7,USE_STDPERIPH_DRIVER
  c include: ..\AT32F403A\cmsis\cm4\core_support;..\AT32F403A\cmsis\cm4\device_support;..\AT32F403A\drivers\inc;..\Inc;..\UI;..\UI\screens;..\UI\components;..\UI\fonts
  memory RVCT4: ROM 0x8000000 size 0x100000
  memory RVCT9: RAM 0x20000000 size 0x38000
  group App
    ../Src/: at32f403a_407_clock.c at32f403a_407_int.c main.c lcd.c timer.c delay.c spim.c usart.c usercode_to_bootloader.c
  group PeriphDriver
    ../AT32F403A/drivers/src/: at32f403a_407_acc.c at32f403a_407_adc.c at32f403a_407_bpr.c at32f403a_407_can.c at32f403a_407_crc.c at32f403a_407_crm.c at32f403a_407_dac.c at32f403a_407_debug.c at32f403a_407_dma.c at32f403a_407_emac.c at32f403a_407_exint.c at32f403a_407_flash.c at32f403a_407_gpio.c at32f403a_407_i2c.c at32f403a_407_misc.c at32f403a_407_pwc.c at32f403a_407_rtc.c at32f403a_407_sdio.c at32f403a_407_spi.c at32f403a_407_tmr.c at32f403a_407_usart.c at32f403a_407_usb.c at32f403a_407_wdt.c at32f403a_407_wwdt.c at32f403a_407_xmc.c
  group Startup
    ../AT32F403A/cmsis/cm4/device_support/startup/mdk/: startup_at32f403a_407.s
  group CMSIS
    ../AT32F403A/cmsis/cm4/device_support/: system_at32f403a_407.c
  group UI
    ../UI/: ui.c ui_helpers.c
    ../UI/components/: ui_comp_hook.c
    ../UI/screens/: ui_Screen1.c ui_Screen2.c ui_Screen3.c
software components: LVGL:Essential 9.1.0, LVGL:Porting:Display 9.1.0
